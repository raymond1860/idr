# Keil uVision project idr.uvproj, settings and files
target idr (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: idr +hex
  c flags: Optimize=8 SizeSpeed=1
  group assembly
    ./: STARTUP.A51
  group c
    ./: main.c secure.c SPI.C uart.c
  group include
    ./: STC15F2K08S2.h secure.h spi.h common.h
