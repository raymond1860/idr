# Keil uVision project tmc.uvproj, settings and files
target ID_READER_DEMO (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: tmc +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group main
    ../source/main/: main.c
  group secure
    ../source/secure/: secure.c
  group spi
    ../source/spi/: SPI.C
